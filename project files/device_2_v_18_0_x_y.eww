<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\v.18.00\device_2_v_18_0_0_2.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\v.18.00\device_2_v_18_1_0_2.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\v.18.00\device_2_v_18_2_0_2.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\v.18.00\device_2_v_18_3_0_2.ewp</path>
    </project>
    <batchBuild />
</workspace>
